do_mender_uboot_auto_configure_prepend() {
    do_copy_laird_config
}

